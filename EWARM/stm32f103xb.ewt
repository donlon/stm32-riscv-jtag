<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Inc</name>
    <file>
      <name>$PROJ_DIR$\..\Inc\debug_defines.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Inc\gdb_regs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Inc\jtag_define.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Inc\jtag_slave_driver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Inc\jtag_slave_ex.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Inc\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Inc\stm32f1xx_hal_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Inc\stm32f1xx_it.h</name>
    </file>
  </group>
  <group>
    <name>Src</name>
    <file>
      <name>$PROJ_DIR$\..\Src\jtag_slave_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\jtag_slave_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\stm32f1xx_hal_msp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\stm32f1xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Src\system_stm32f1xx.c</name>
    </file>
  </group>
  <group>
    <name>STM32F1xx_HAL_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_adc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_cortex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dac_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_eth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_flash_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_gpio_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_hcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_irda.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_mmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_nand.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_nor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pccard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pcd_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rcc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_rtc_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_sd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_smartcard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_sram.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_tim_ex.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Drivers\STM32F1xx_HAL_Driver\Src\stm32f1xx_hal_wwdg.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\startup_stm32f103xb.s</name>
  </file>
</project>


